Commit message: Fixes

File: neural_ik/urdf/dof2d.urdf (robot description, URDF)
Before this commit: robot omnipointer, 4 links, 3 joints
Joints:
- joint arm_joint_1: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 1 0 rpy=0 0 0
